Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2018-10-02T09:59:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20171027_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Tue Oct 02 09:59:54 2018* Host: NCL-PI04* Database: C:\Users\BocianP\AppData\Local\Temp\{ED91AB6E-957F-4098-A3F5-D94191F676BB}\ifc* Database version: 5507* Database creation date: Tue Oct 02 09:59:51 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Tue Oct 02 09:59:51 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Tue Oct 02 09:59:51 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: HR17N, NBS_NiftyliftLtd_SlfPrplldPltfrms_HR17N:HR17N:9805
In: Level 1
Type - Classification: TE_30_30_60_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_NiftyliftLtd_SelfPropelledPlatforms_HR17N; ManufacturerName: Niftylift Ltd; ManufacturerURL: http://www.niftylift.com/uk; NBSCertification: www.nationalbimlibrary.com/cert/cgntnanq; NBSDescription: n/a; NBSReference: n/a; ProductInformation: http://www.niftylift.com/uk/products/cherry-picker/self-propelled/hr17n#specifications; Revision: n/a; Uniclass2015Title: Self propelled platforms; Uniclass2015Code: TE_30_30_60_50; Uniclass2015Version: Tools and Equipment v1.5; Version: 1
Type - NBS_Data - WorkingOutreach: 9700 mm; PlatformHeight: 15000 mm; CageSize: 1500 x 800 mm; PowerOptions: Battery, hybrid; MinWeight: 7650 kg; SafeWorkingLoad: 225 kg; Gradeability: 25% (14°); TurningRadius: 3500 mm; TravelSpeed: 3.5 km/h; FlyBoomArc: 150°; CageRotation: 180°
Type - Pset_BuildingElementProxyCommon - FireRating: n/a; IsExternal: yes; LoadBearing: yes; Reference: n/a; Status: New; ThermalTransmittance: 0
Type - IFC - IfcExportAs: IfcBuildingElementProxyType
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: TE_30_30_60_50:Self propelled platforms; CodePerformance: n/a; Color: Green, white; Constituents: n/a; Description: Self-propelled two person heightrider with multi-function controls that can deliver precision, in making tasking easier and quicker to complete; DurationUnit: year; ExpectedLife: n/a; Features: Toughcage with SiOPS, zero tail-swing, rotating cage, multi-function controls, efficient power system, narrow chassis, optional non marking tyres; Finish: n/a; Grade: n/a; Manufacturer: marketing@niftylift.com; Material: Steel; ModelNumber: HR17; ModelReference: HR17N; Name: SelfPropelledPlatforms_HR17N_NiftyliftLtd; NominalHeight: 15500 mm; NominalLength: 6400 mm; NominalWidth: 1500 mm; ReplacementCost: n/a; Shape: n/a; Size: 17000 x 6400 x 1500 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcBuildingElementProxy: HR17N (2)
In: Level 1
Type - Classification: TE_30_30_60_50 (Uniclass2015); Material: NBS_Concept
Type - BOS_General - Author: NBS; BIMObjectName: NBS_NiftyliftLtd_SelfPropelledPlatforms_HR17N; ManufacturerName: Niftylift Ltd; ManufacturerURL: http://www.niftylift.com/uk; NBSCertification: www.nationalbimlibrary.com/cert/cgntnanq; NBSDescription: n/a; NBSReference: n/a; ProductInformation: http://www.niftylift.com/uk/products/cherry-picker/self-propelled/hr17n#specifications; Revision: n/a; Uniclass2015Title: Self propelled platforms; Uniclass2015Code: TE_30_30_60_50; Uniclass2015Version: Tools and Equipment v1.5; Version: 1
Type - NBS_Data - WorkingOutreach: 9700 mm; PlatformHeight: 15000 mm; CageSize: 1500 x 800 mm; PowerOptions: Battery, hybrid; MinWeight: 7650 kg; SafeWorkingLoad: 225 kg; Gradeability: 25% (14°); TurningRadius: 3500 mm; TravelSpeed: 3.5 km/h; FlyBoomArc: 150°; CageRotation: 180°
Type - Pset_BuildingElementProxyCommon - IsExternal: yes; LoadBearing: yes; ThermalTransmittance: 0; FireRating: n/a; Reference: n/a; Status: New
Type - IFC - IfcExportAs: IfcBuildingElementProxyType
Type - COBie - AccessibilityPerformance: n/a; AssetType: Movable; Category: TE_30_30_60_50:Self propelled platforms; CodePerformance: n/a; Color: Green, white; Constituents: n/a; Description: Self-propelled two person heightrider with multi-function controls that can deliver precision, in making tasking easier and quicker to complete; DurationUnit: year; ExpectedLife: n/a; Features: Toughcage with SiOPS, zero tail-swing, rotating cage, multi-function controls, efficient power system, narrow chassis, optional non marking tyres; Finish: n/a; Grade: n/a; Manufacturer: marketing@niftylift.com; Material: Steel; ModelNumber: HR17; ModelReference: HR17N; Name: SelfPropelledPlatforms_HR17N_NiftyliftLtd; NominalHeight: 15500 mm; NominalLength: 6400 mm; NominalWidth: 1500 mm; ReplacementCost: n/a; Shape: n/a; Size: 17000 x 6400 x 1500 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
Name (NBS_NiftyliftLtd_SlfPrplldPltfrms_HR17N:HR17N:...)
58611
58617
